# Keil uVision project PMSM_Control.uvprojx, settings and files
target PMSM_Control (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: PMSM_Control +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx,MOTOR_CONTROL_FIXED
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;..\BSP\STM32\inc;..\Motor_Task\MATH_LIB\Inc;..\Motor_Task\Command\Inc;..\Motor_Task\Control_Task\Fixed\Inc;..\Motor_Task\Control_Task\Float\Inc;..\Motor_Task\DIAG\Inc;..\System\Inc
  asm include: ../Middlewares/ST/ARM/DSP/Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c app_freertos.c adc.c dma.c fdcan.c opamp.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4lf_math.lib
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group BSP
    ../BSP/STM32/src/: Bsp_STM32G431.c
  group Motor_Control
    ../System/Inc/: Motor_FOC_Config.h Motor_Control.h
    ../System/Src/: Motor_Control.c
    ../Motor_Task/Control_Task/Float/Inc/: Motor_Lookup_Tables.h
    ../Motor_Task/MATH_LIB/Src/: Hal_Math.c
  group Motor_FOC_Float
    ../Motor_Task/Control_Task/Float/Src/: Current_Loop_Float.c Speed_Loop_Float.c System_Loop_Float.c Observer_Float.c SVPWM_Float.c
  group Motor_FOC_Fixed
    ../Motor_Task/Control_Task/Fixed/Src/: Current_Loop_Fixed.c Speed_Loop_Fixed.c System_Loop_FIxed.c Observer_Fixed.c SVPWM_Fixed.c
  group Motor_Command
    ../Motor_Task/Command/Src/: button_led.c
  group Motor_Diag
    ../Motor_Task/DIAG/Src/: Diag_List.c Motor_Diag.c System_Diag.c
software components: CMSIS:CORE 4.3.0
